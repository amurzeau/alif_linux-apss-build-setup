
RDEPENDS_packagegroup-core-apss-base_remove += "helloworld helloworld-daemon"
RDEPENDS_packagegroup-core-apss-base_append += "setup-network"
