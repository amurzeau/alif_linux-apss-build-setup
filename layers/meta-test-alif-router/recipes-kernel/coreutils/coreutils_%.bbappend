do_configure_prepend() {
	export FORCE_UNSAFE_CONFIGURE=1
}
