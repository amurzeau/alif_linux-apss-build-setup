EXTRA_OECONF = " \
                 --without-cli \
                 --with-mini-gmp \
                 "
DEPENDS_remove = "readline gmp"
PACKAGECONFIG = ""
